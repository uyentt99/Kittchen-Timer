# Keil uVision project 7seq.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 7seq +hex
  c flags: Optimize=8 SizeSpeed=1
  group Group 1
    ./: main.a51
